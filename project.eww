<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\app.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\lib\lib.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Build Application</name>
            <member>
                <project>lib</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>app</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
